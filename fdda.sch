v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {nmos4.sym} 880 -420 0 0 {name=M1 model=nmos w=5u l=0.18u del=0 m=1}
